# Keil uVision project EpaperModuleTest_GD32F103.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EpaperModuleTest_GD32F103 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD
  c include: ..\GD32F103\CMSIS\GD\GD32F10x\Include;..\GD32F103\CMSIS;..\GD32F103\GD32F10x_standard_peripheral\Include;..\GD32F103\GD32F10x_usbd_library\usbd\Include;..\GD32F103\GD32F10x_usbd_library\device\Include;..\Inc;..\Epaper
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../Src/: gd32f10x_it.c main.c systick.c board.c
  group CMSIS
    ../GD32F103/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ../GD32F103/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ../GD32F103/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_md.s
  group Epaper
    ../Epaper/: epaper.c
